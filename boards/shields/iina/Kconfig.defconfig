## boards/shields/iina/Kconfig.defconfig
```kconfig
if SHIELD_IINA

config ZMK_KEYBOARD_NAME
    default "iina"

endif # SHIELD_IINA
```
